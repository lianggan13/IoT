# Keil uVision project C51.uvproj, settings and files
target AT89C51 (MCS-51)
  device: AT89F51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: C51 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Program
    ./Program/: main.c
  group NRF24L01
    ./NRF24L01/: NRF24L01.c NRF24L01.h
  group Test
    ./Test/: test.c
  group Keyboard
    ./Keyboard/: KeyMatrix.c KeyMatrix.h
  group LED
    ./LED/: Led_8x8.c Led_8x8.h
  group Utility
    ./Utility/: delay.c delay.h
  group HC595
    ./HC595/: HC595.c HC595.h
